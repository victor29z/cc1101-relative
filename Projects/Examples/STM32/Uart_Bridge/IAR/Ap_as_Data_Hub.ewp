# IAR project Ap_as_Data_Hub.ewp, settings and files
configuration CC1101-UartBridge-LinkTo (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: MACH_RBT6; CFG_LINK_TO; MRFI_CC1101; DEBUG_SPI_; I_WANT_TO_CHANGE_DEFAULT_ROM_DEVICE_ADDRESS_PSEUDO_CODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\STM32; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\simpliciti\nwk; ..\..\..\..\..\Components\simpliciti\nwk_applications; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Ap_as_Data_Hub.srec
  ILINK.IlinkOutputFile: Ap_as_Data_Hub.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CC1101-UartBridge-LinkListen (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MACH_RBT6; CFG_LINK_LISTEN; MRFI_CC1101; DEBUG_SPI_; I_WANT_TO_CHANGE_DEFAULT_ROM_DEVICE_ADDRESS_PSEUDO_CODE
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/boards/STM32/: bsp_button_defs.h bsp_led_defs.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
  group peer applications/application
    ../../../Applications/: main_UART_Bridge.c
    ../../../../../Components/bsp/drivers/code/: uart_intfc.c uart_stm32.c
  group STM32
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../../../../Components/bsp/boards/STM32/: system_stm32f10x.c
  group STM32F10x_StdPeriph
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
