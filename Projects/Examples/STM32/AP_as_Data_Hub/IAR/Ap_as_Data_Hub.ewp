# IAR project Ap_as_Data_Hub.ewp, settings and files
configuration CC1101-Access Point (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: MACH_RBT6; CFG_ACCESS_POINT; MRFI_CC1101
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport; ..\..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\STM32; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\simpliciti\nwk; ..\..\..\..\..\Components\simpliciti\nwk_applications; 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Ap_as_Data_Hub.srec
  ILINK.IlinkOutputFile: Ap_as_Data_Hub.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CC1101-Channel Sniffer (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
configuration CC1101-Range Extender (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
configuration CC1101-End Device (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MACH_RBT6; CFG_END_DEVICE; MRFI_CC1101
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/boards/STM32/: bsp_button_defs.h bsp_led_defs.h
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_ioctl.c nwk_join.c nwk_link.c nwk_mgmt.c nwk_ping.c nwk_pll.c nwk_security.c
  group peer applications/application/Access Point
    ../../../Applications/: main_AP_Async_Listen_autoack.c
  group peer applications/application/Channel Sniffer
    ../../../Applications/: main_ED_Sniffer.c
  group peer applications/application/End Device
    ../../../Applications/: main_manyEDs_autoack.c
  group peer applications/application/Range Extender
    ../../../Applications/: main_AP_RE.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/Channel Sniffer
    Configuration/Channel_Sniffer/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
  group STM32
    ../../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../../../../Components/bsp/boards/STM32/: system_stm32f10x.c
  group STM32F10x_StdPeriph
    ../../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
